# Keil uVision project car.uvprojx, settings and files
target Target 1 (6210000::V6.21::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: hub
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: ..;..\..\..
  asm include: ../
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group car
    ../inc/: startup.s PLL.c tm4c123gh6pm.h ST7735.c UART.c LED.c Timer0A.c UART5.c PWM.c esp8266_base.c
    ../lib/RGB/: RGB.c
    ./: car_main.c
software components: CMSIS:CORE 5.6.0
