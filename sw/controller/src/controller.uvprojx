# Keil uVision project controller.uvprojx, settings and files
target Target 1 (6210000::V6.21::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: controller.elf
  AfterMake: fromelf.exe --bin Objects/controller.elf --output Objects/controller.bin
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: ..;..\..\..
  asm include: ../
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group controller
    ../inc/: startup.s PLL.c tm4c123gh6pm.h ST7735.c UART.c Unified_Port_Init.c LED.c Timer0A.c random.s ADCSWTrigger.c PWM.c UART5.c Timer4A.c LaunchPad.c Timer5A.c esp8266_base.c Timer3A.c
    ../lib/RGB/: RGB.c
    ./: Display.c display_testmain.c engine_testmain.c DriveSim.c controller_main.c EngineSound.c DAC.c Communicate.c ControllerBoard.c
software components: CMSIS:CORE 5.6.0
